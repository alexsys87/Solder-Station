# IAR project SolderStation.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401CC ST STM32F401CC
  General.CoreVariant: 39
  General.FPU2: 4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F401xC; HSE_VALUE=25000000
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.IccLang: 0
  ICCARM.CCDiagSuppress: Pa082,Pa089
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: SolderStation.hex
  ILINK.IlinkOutputFile: SolderStation.out
  ILINK.IlinkIcfFile: stm32f401xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group Application
    ../Core/Src/: buzzer.c flash.c fonts_digits.c fonts_small.c gfx.c heater.c input.c iron.c main.c menu.c motion.c oled.c rtc.c settings.c sys.c telemetry.c ui.c
  group Include
    ../Core/Inc/: board.h buzzer.h config.h flash.h fonts.h gfx.h heater.h input.h iron.h menu.h motion.h oled.h rtc.h settings.h sys.h telemetry.h ui.h
  group CMSIS
    ./: startup_stm32f401xc.s
    ../Core/Src/: system_stm32f4xx.c
